// weegfx.cpp - Lightweight graphics library implementation
//
// Copyright (c) 2016 Patrick Dowling

#include "weegfx.h"
#include <string.h>
#include <stdio.h>
#include <stdarg.h>
#include <stdlib.h>

// ASCII printable character range
static constexpr char ASCII_PRINTABLE_START = 32;
static constexpr char ASCII_PRINTABLE_END = 126;

// Buffer size for printf
static constexpr size_t PRINTF_BUFFER_SIZE = 64;

// Simple 5x7 font - basic ASCII characters starting from space (32)
static const uint8_t font5x7[] = {
  0x00, 0x00, 0x00, 0x00, 0x00, // space
  0x00, 0x00, 0x5F, 0x00, 0x00, // !
  0x00, 0x07, 0x00, 0x07, 0x00, // "
  0x14, 0x7F, 0x14, 0x7F, 0x14, // #
  0x24, 0x2A, 0x7F, 0x2A, 0x12, // $
  0x23, 0x13, 0x08, 0x64, 0x62, // %
  0x36, 0x49, 0x55, 0x22, 0x50, // &
  0x00, 0x05, 0x03, 0x00, 0x00, // '
  0x00, 0x1C, 0x22, 0x41, 0x00, // (
  0x00, 0x41, 0x22, 0x1C, 0x00, // )
  0x08, 0x2A, 0x1C, 0x2A, 0x08, // *
  0x08, 0x08, 0x3E, 0x08, 0x08, // +
  0x00, 0x50, 0x30, 0x00, 0x00, // ,
  0x08, 0x08, 0x08, 0x08, 0x08, // -
  0x00, 0x60, 0x60, 0x00, 0x00, // .
  0x20, 0x10, 0x08, 0x04, 0x02, // /
  0x3E, 0x51, 0x49, 0x45, 0x3E, // 0
  0x00, 0x42, 0x7F, 0x40, 0x00, // 1
  0x42, 0x61, 0x51, 0x49, 0x46, // 2
  0x21, 0x41, 0x45, 0x4B, 0x31, // 3
  0x18, 0x14, 0x12, 0x7F, 0x10, // 4
  0x27, 0x45, 0x45, 0x45, 0x39, // 5
  0x3C, 0x4A, 0x49, 0x49, 0x30, // 6
  0x01, 0x71, 0x09, 0x05, 0x03, // 7
  0x36, 0x49, 0x49, 0x49, 0x36, // 8
  0x06, 0x49, 0x49, 0x29, 0x1E, // 9
  0x00, 0x36, 0x36, 0x00, 0x00, // :
  0x00, 0x56, 0x36, 0x00, 0x00, // ;
  0x00, 0x08, 0x14, 0x22, 0x41, // <
  0x14, 0x14, 0x14, 0x14, 0x14, // =
  0x41, 0x22, 0x14, 0x08, 0x00, // >
  0x02, 0x01, 0x51, 0x09, 0x06, // ?
  0x32, 0x49, 0x79, 0x41, 0x3E, // @
  0x7E, 0x11, 0x11, 0x11, 0x7E, // A
  0x7F, 0x49, 0x49, 0x49, 0x36, // B
  0x3E, 0x41, 0x41, 0x41, 0x22, // C
  0x7F, 0x41, 0x41, 0x22, 0x1C, // D
  0x7F, 0x49, 0x49, 0x49, 0x41, // E
  0x7F, 0x09, 0x09, 0x01, 0x01, // F
  0x3E, 0x41, 0x41, 0x51, 0x32, // G
  0x7F, 0x08, 0x08, 0x08, 0x7F, // H
  0x00, 0x41, 0x7F, 0x41, 0x00, // I
  0x20, 0x40, 0x41, 0x3F, 0x01, // J
  0x7F, 0x08, 0x14, 0x22, 0x41, // K
  0x7F, 0x40, 0x40, 0x40, 0x40, // L
  0x7F, 0x02, 0x04, 0x02, 0x7F, // M
  0x7F, 0x04, 0x08, 0x10, 0x7F, // N
  0x3E, 0x41, 0x41, 0x41, 0x3E, // O
  0x7F, 0x09, 0x09, 0x09, 0x06, // P
  0x3E, 0x41, 0x51, 0x21, 0x5E, // Q
  0x7F, 0x09, 0x19, 0x29, 0x46, // R
  0x46, 0x49, 0x49, 0x49, 0x31, // S
  0x01, 0x01, 0x7F, 0x01, 0x01, // T
  0x3F, 0x40, 0x40, 0x40, 0x3F, // U
  0x1F, 0x20, 0x40, 0x20, 0x1F, // V
  0x7F, 0x20, 0x18, 0x20, 0x7F, // W
  0x63, 0x14, 0x08, 0x14, 0x63, // X
  0x03, 0x04, 0x78, 0x04, 0x03, // Y
  0x61, 0x51, 0x49, 0x45, 0x43, // Z
  0x00, 0x00, 0x7F, 0x41, 0x41, // [
  0x02, 0x04, 0x08, 0x10, 0x20, // backslash
  0x41, 0x41, 0x7F, 0x00, 0x00, // ]
  0x04, 0x02, 0x01, 0x02, 0x04, // ^
  0x40, 0x40, 0x40, 0x40, 0x40, // _
  0x00, 0x01, 0x02, 0x04, 0x00, // `
  0x20, 0x54, 0x54, 0x54, 0x78, // a
  0x7F, 0x48, 0x44, 0x44, 0x38, // b
  0x38, 0x44, 0x44, 0x44, 0x20, // c
  0x38, 0x44, 0x44, 0x48, 0x7F, // d
  0x38, 0x54, 0x54, 0x54, 0x18, // e
  0x08, 0x7E, 0x09, 0x01, 0x02, // f
  0x08, 0x14, 0x54, 0x54, 0x3C, // g
  0x7F, 0x08, 0x04, 0x04, 0x78, // h
  0x00, 0x44, 0x7D, 0x40, 0x00, // i
  0x20, 0x40, 0x44, 0x3D, 0x00, // j
  0x00, 0x7F, 0x10, 0x28, 0x44, // k
  0x00, 0x41, 0x7F, 0x40, 0x00, // l
  0x7C, 0x04, 0x18, 0x04, 0x78, // m
  0x7C, 0x08, 0x04, 0x04, 0x78, // n
  0x38, 0x44, 0x44, 0x44, 0x38, // o
  0x7C, 0x14, 0x14, 0x14, 0x08, // p
  0x08, 0x14, 0x14, 0x18, 0x7C, // q
  0x7C, 0x08, 0x04, 0x04, 0x08, // r
  0x48, 0x54, 0x54, 0x54, 0x20, // s
  0x04, 0x3F, 0x44, 0x40, 0x20, // t
  0x3C, 0x40, 0x40, 0x20, 0x7C, // u
  0x1C, 0x20, 0x40, 0x20, 0x1C, // v
  0x3C, 0x40, 0x30, 0x40, 0x3C, // w
  0x44, 0x28, 0x10, 0x28, 0x44, // x
  0x0C, 0x50, 0x50, 0x50, 0x3C, // y
  0x44, 0x64, 0x54, 0x4C, 0x44, // z
  0x00, 0x08, 0x36, 0x41, 0x00, // {
  0x00, 0x00, 0x7F, 0x00, 0x00, // |
  0x00, 0x41, 0x36, 0x08, 0x00, // }
  0x08, 0x08, 0x2A, 0x1C, 0x08, // ~
};

namespace weegfx {

void Graphics::Begin(uint8_t *frame, ClearFrame clear_frame) {
  frame_ = frame;
  print_x_ = 0;
  print_y_ = 0;
  if (clear_frame == CLEAR_FRAME_ENABLE) {
    memset(frame_, 0, kFrameSize);
  }
}

void Graphics::End() {
  frame_ = nullptr;
}

void Graphics::plot(int x, int y) {
  if (!valid(x, y)) return;
  // Frame buffer is organized as pages (8 rows per page)
  size_t page = y / 8;
  size_t bit = y % 8;
  frame_[page * kWidth + x] |= (1 << bit);
}

void Graphics::unplot(int x, int y) {
  if (!valid(x, y)) return;
  size_t page = y / 8;
  size_t bit = y % 8;
  frame_[page * kWidth + x] &= ~(1 << bit);
}

void Graphics::setPixel(int x, int y) {
  plot(x, y);
}

void Graphics::clearPixel(int x, int y) {
  unplot(x, y);
}

void Graphics::drawHLine(int x, int y, int w) {
  for (int i = 0; i < w; ++i) {
    plot(x + i, y);
  }
}

void Graphics::drawVLine(int x, int y, int h) {
  for (int i = 0; i < h; ++i) {
    plot(x, y + i);
  }
}

void Graphics::drawLine(int x0, int y0, int x1, int y1) {
  // Bresenham's line algorithm
  int dx = abs(x1 - x0);
  int dy = abs(y1 - y0);
  int sx = x0 < x1 ? 1 : -1;
  int sy = y0 < y1 ? 1 : -1;
  int err = dx - dy;

  while (true) {
    plot(x0, y0);
    if (x0 == x1 && y0 == y1) break;
    int e2 = 2 * err;
    if (e2 > -dy) {
      err -= dy;
      x0 += sx;
    }
    if (e2 < dx) {
      err += dx;
      y0 += sy;
    }
  }
}

void Graphics::drawRect(int x, int y, int w, int h) {
  // Filled rectangle
  for (int i = 0; i < h; ++i) {
    drawHLine(x, y + i, w);
  }
}

void Graphics::drawFrame(int x, int y, int w, int h) {
  // Rectangle outline
  drawHLine(x, y, w);
  drawHLine(x, y + h - 1, w);
  drawVLine(x, y, h);
  drawVLine(x + w - 1, y, h);
}

void Graphics::invertRect(int x, int y, int w, int h) {
  for (int j = 0; j < h; ++j) {
    for (int i = 0; i < w; ++i) {
      int px = x + i;
      int py = y + j;
      if (valid(px, py)) {
        size_t page = py / 8;
        size_t bit = py % 8;
        frame_[page * kWidth + px] ^= (1 << bit);
      }
    }
  }
}

void Graphics::drawCircle(int cx, int cy, int r) {
  // Midpoint circle algorithm
  int x = r;
  int y = 0;
  int err = 0;

  while (x >= y) {
    plot(cx + x, cy + y);
    plot(cx + y, cy + x);
    plot(cx - y, cy + x);
    plot(cx - x, cy + y);
    plot(cx - x, cy - y);
    plot(cx - y, cy - x);
    plot(cx + y, cy - x);
    plot(cx + x, cy - y);

    y += 1;
    err += 1 + 2 * y;
    if (2 * (err - x) + 1 > 0) {
      x -= 1;
      err += 1 - 2 * x;
    }
  }
}

void Graphics::drawBitmap8(int x, int y, int w, const uint8_t *data) {
  for (int col = 0; col < w; ++col) {
    uint8_t bits = data[col];
    for (int bit = 0; bit < 8; ++bit) {
      if (bits & (1 << bit)) {
        plot(x + col, y + bit);
      }
    }
  }
}

void Graphics::setPrintPos(int x, int y) {
  print_x_ = x;
  print_y_ = y;
}

void Graphics::print(char c) {
  if (c == '\n') {
    print_x_ = 0;
    print_y_ += 8;
    return;
  }
  
  if (c < ASCII_PRINTABLE_START || c > ASCII_PRINTABLE_END) c = '?';
  
  int index = (c - ASCII_PRINTABLE_START) * 5;
  for (int i = 0; i < 5; ++i) {
    uint8_t col = font5x7[index + i];
    for (int j = 0; j < 7; ++j) {
      if (col & (1 << j)) {
        plot(print_x_ + i, print_y_ + j);
      }
    }
  }
  print_x_ += 6; // 5 pixels + 1 pixel spacing
}

void Graphics::print(const char *s) {
  while (*s) {
    print(*s++);
  }
}

void Graphics::print(int n) {
  char buf[16];
  snprintf(buf, sizeof(buf), "%d", n);
  print(buf);
}

void Graphics::printf(const char *fmt, ...) {
  char buf[PRINTF_BUFFER_SIZE];
  va_list args;
  va_start(args, fmt);
  vsnprintf(buf, sizeof(buf), fmt, args);
  va_end(args);
  print(buf);
}

void Graphics::drawStr(int x, int y, const char *s) {
  setPrintPos(x, y);
  print(s);
}

}; // namespace weegfx
